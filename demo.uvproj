# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: demo +hex
  c flags: Optimize=9
  c include: ..\demo;.\User\USART;.\Devices\KEY;.\Devices\DS18B20;.\Devices\OLED
  group Startup
    ./: STARTUP.A51 Conf_tny.A51
  group User
    ./: main.c
    ./User/USART/: usart.c
    ./Devices/OLED/: oledfont.c
  group Devices
    ./Devices/KEY/: key.c
    ./Devices/DS18B20/: ds18b20.c
    ./Devices/OLED/: oled.c
